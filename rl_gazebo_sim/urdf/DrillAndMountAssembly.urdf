Commit message: updated weight

File: rl_gazebo_sim/urdf/DrillAndMountAssembly.urdf (robot description, URDF)
Before this commit: robot DrillAndMountAssembly, 1 links, 0 joints
Links:
- link DrillAndMountAssembly: mass 0 -> 0.8
